# IAR project App_m1000.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\FWlib\inc; ..\CMSIS; ..\System\delay; ..\System\sys; ..\USB_lib\inc; USB_Config\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Iar7_app.hex
  ILINK.IlinkOutputFile: App_m1000.out
  ILINK.IlinkIcfFile: stm32f103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group FW_lib
    ../FWlib/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group ReadMe
    ../: ReadMe.txt
    ./: test.txt
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
  group USB_lib
    ../USB_lib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ./: cpu_init.c main.c myiic2.c screen_iic.cpp stm32f10x_it.c
  group User/mpu6500
    ./: mpu6500.c mpuiic.c spi.c
  group User/usb_config
    usb_config/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
