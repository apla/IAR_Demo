# IAR project Iar_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\FWlib\inc; ..\CMSIS; ..\System\delay; ..\System\sys; ..\USB_lib\inc; USB_Config\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Iar_Demo.hex
  ILINK.IlinkOutputFile: Iar_Demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group FW_lib
    ../FWlib/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group ReadMe
    ../: ReadMe.txt
    ./: test.txt
  group System
    ../System/delay/: delay.c
  group User
    ./: cpu_init.c i2c1_sensor.c i2c2_screen.c main.c stm32f10x_it.c
    ../System/sys/: sys.c
